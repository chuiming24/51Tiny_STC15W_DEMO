# Keil uVision project MIAN.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: MIAN +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ZLG_GUI;.\
  group Source Group 1
    ./: mian.c Conf_tny.A51 12864.c delay.c gpio.c iic.c pwm.c 12864_table.c
